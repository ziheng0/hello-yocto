## build/conf/bblayers.conf
```bitbake
BBPATH := "${TOPDIR}"
BBFILES ?= ""
BBLAYERS = "/home/q/test/hello-yocto/meta-hello"
```
